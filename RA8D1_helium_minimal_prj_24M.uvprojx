# Keil uVision project RA8D1_helium_minimal_prj_24M.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2-dev1
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: RA8D1_helium_minimal_prj +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1
  c misc: -Omax -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
target Release (6210000::V6.21::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2-dev1
  cpu: as above
  output: RA8D1_helium_minimal_prj
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1
  c misc: as above
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
software components: Flex Software:RA Configuration 1.0.0
